# Keil uVision project nRF9160_ns.uvprojx, settings and files
target Source (6160000::V6.16::ARMCLANG)
  device: nRF9160_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x0003E000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: nRF9160_ns
  c flags: Optim=1 v6Lang=4 v6LangP=2 wLevel=3
  c define: NRF_TRUSTZONE_NONSECURE __SUPPORT_RESET_HALT_AFTER_BTL=0 NRF9160_XXAA INITIALIZE_USER_SECTIONS NRFXLIB_V1 NRFX_PRS_ENABLED NRFX_UARTE_ENABLED NRFX_UARTE1_ENABLED NRFX_UARTE2_ENABLED NRFX_IPC_ENABLED NRFX_SPIS_ENABLED NRFX_SPIS0_ENABLED NRFX_TWIM_ENABLED NRFX_TWIM0_ENABLED NRFX_NVMC_ENABLED SYSVIEW_ENABLED=1 LFS_NO_MALLOC LFS_NO_ERROR LFS_NO_WARN LFS_NO_DEBUG MQTT_DO_NOT_USE_CUSTOM_CONFIG CONFIG_NRF_MODEM_LIB_TRACE_ENABLED=0 TARGET_DEVICE_NRF9160DK INIT_LOG_LEVEL=loglevel_info
  c include: ..\Config;..\Lib\nRF\Include;..\Lib\nrfx;..\Lib\nrfx\mdk;..\Lib\nrfx\drivers\include;..\Lib\nrfxlib\nrf_modem\include;..\Lib\littlefs;..\Lib\FreeRTOS\Source\include;..\Lib\FreeRTOS\Source\portable\GCC\ARM_CM33\secure;..\Lib\FreeRTOS\Source\portable\GCC\ARM_CM33\non_secure;..\Lib\FreeRTOS-Plus\Source\Application-Protocols\coreMQTT\source\include;..\Lib\FreeRTOS-Plus\Source\Application-Protocols\coreMQTT\source\interface;..\Lib\embedded-cli\lib\include;..\Lib\SystemView\SEGGER;..\Lib\SystemView\Config;..\Lib\SystemView\Sample\FreeRTOSV10.4;.\
  asm define: __STACK_SIZE=2048 __HEAP_SIZE=128
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x36000
  scatter file: .\nRF9160_ns.sct
  group CMSE Library
    ../Secure/Objects/: nRF9160_s_CMSE_Lib.o
  group FreeRTOS
    ../Lib/FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Lib/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Lib/FreeRTOS/Source/portable/Common/: mpu_wrappers.c
    ../Lib/FreeRTOS/Source/portable/GCC/ARM_CM33/non_secure/: port.c portasm.h portmacro.h portasm.c
  group Config
    ../Config/: FreeRTOSConfig.h
  group Application
    ./: modem.c main_ns.c board.c app.c blinky.c cli.c log.c twdt.c twim.c gpio.c uart.c spim.c spimtest.c spis.c spistest.c dmm.c slm.c fs.c os.c mqtt.c tls.c
  group System
    ./: stdout_user.c stdin_user.c
    ../Lib/nrfx/drivers/src/: nrfx_uarte.c nrfx_twim.c nrfx_spim.c nrfx_spis.c nrfx_ipc.c
    ../Lib/nrfx/drivers/src/prs/: nrfx_prs.c
    ../Lib/embedded-cli/lib/src/: embedded_cli.c
    ../Lib/nrfxlib/nrf_modem/lib/cortex-m33/hard-float/: libmodem_log.a
    ../lib/nrfx/drivers/src/: nrfx_nvmc.c
    ../lib/littlefs/: lfs.c lfs_util.c
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 8.44.1
