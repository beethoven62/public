# Keil uVision project nRF9160_s.uvprojx, settings and files
target Source (6160000::V6.16::ARMCLANG)
  device: nRF9160_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x0003E000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: nRF9160_s
  c flags: Optim=2 v6Lang=4 v6LangP=2 wLevel=3
  c define: NRF9160_XXAA __NRF_FAMILY __SUPPORT_RESET_HALT_AFTER_BTL=0
  c include: ..\Config;..\Lib\FreeRTOS\Source\include;..\Lib\FreeRTOS\Source\portable\GCC\ARM_CM33\secure
  asm define: __STACK_SIZE=128 __HEAP_SIZE=128
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20036000 size 0x8000
  scatter file: .\nRF9160_s.sct
  group SecureContext
    ../Lib/FreeRTOS/Source/portable/GCC/ARM_CM33/secure/: secure_context.h secure_context.c secure_context_port.c secure_port_macros.h
  group SecureInit
    ../Lib/FreeRTOS/Source/portable/GCC/ARM_CM33/secure/: secure_init.h secure_init.c
  group SecureHeap
    ../Lib/FreeRTOS/Source/portable/GCC/ARM_CM33/secure/: secure_heap.h secure_heap.c
  group Application
    ./: main_s.c
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0, Device:Startup 8.44.1
